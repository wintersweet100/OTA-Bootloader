# Keil uVision project Bootloader_hal_1227_2.uvprojx, settings and files
target Bootloader_hal_1227_2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader_hal_1227_2 +hex
  AfterMake: fromelf --text -a -c --output=bootloader.dis Bootloader_hal_1227_2\Bootloader_hal_1227_2.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/Application;../Drivers/rz;../Drivers/Users;../Drivers/W5500;..\Drivers\FileTransfer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: Bootloader_hal_1227_2\Bootloader_hal_1227_2.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/user
    ../Drivers/Application/: shell.c string.c types.h parser.c command.c help_cmd.c ring_buffer.c file.c go_cmd.c flash_cmd.c mem_cmd.c stm_flash.c Init_cmd.c
  group rz
    ../Drivers/rz/: crctab.c lrz.c mrz.c rbsb.c zm.c zreadline.c
  group esp_01s
    ../Drivers/Users/: bsp_esp8266.c bsp_esp8266_test.c core_delay.c
  group w5500_tcp
    ../Drivers/W5500/: w5500_conf.c w5500.c socket.c utility.c tcp_demo.c
  group FileTransfer
    ../Drivers/FileTransfer/: FileTransferProtocol.c FileTransferReceiver.c
software components: CMSIS:CORE 4.3.0
