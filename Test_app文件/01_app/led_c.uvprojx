# Keil uVision project led_c.uvprojx, settings and files
target led_c (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_c +hex
  AfterMake: fromelf  --bin  --output=app.bin  Objects\led_c.axf
  AfterMake: fromelf  --text  -a -c  --output=app.dis  Objects\led_c.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\led_c.sct
  group main
    ./: main.c
  group cpu
    ./: start.s
  group uart
    ./: uart.c
